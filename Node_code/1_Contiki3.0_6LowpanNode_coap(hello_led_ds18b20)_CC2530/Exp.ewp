# IAR project Exp.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: NETSTACK_CONF_WITH_IPV6=1; SLIP_ARCH_CONF_ENABLE=1
  ICC8051.CCDiagSuppress: Pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: contiki-3.0\core\; contiki-3.0\core\lib\; contiki-3.0\cpu\; contiki-3.0\core\sys\; contiki-3.0\platform\cc2530dk\; contiki-3.0\cpu\cc253x\; contiki-3.0\core\net\; contiki-3.0\apps\rest-engine\; contiki-3.0\apps\er-coap\; contiki-3.0\dev\ds18b20\; $TOOLKIT_DIR$\inc\dlib\c\; $TOOLKIT_DIR$\inc\clib\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group contiki-app
    contiki-3.0/examples/cc2530dk/udp-ipv6/: client.c server.c
    contiki-3.0/examples/cc26xx/cc26xx-web-demo/: coap-server.c
    contiki-3.0/apps/er-coap/: er-coap-engine.c er-coap-observe.c er-coap-res-well-known-core.c er-coap-transactions.c er-coap.c
    contiki-3.0/examples/er-rest-example/: er-example-client.c er-example-server.c
    contiki-3.0/examples/er-rest-example/resources/: res-ds18b20.c res-hello.c res-leds.c
    contiki-3.0/apps/rest-engine/: rest-engine.c
    contiki-3.0/core/net/ip/: uip-udp-packet.c
  group contiki-border
    contiki-3.0/cpu/cc253x/dev/: cc2530-rf.c
    contiki-3.0/core/net/mac/: csma.c frame802154.c framer-802154.c framer.c mac-sequence.c mac.c nullrdc.c
    contiki-3.0/core/net/: netstack.c
    contiki-3.0/core/net/llsec/: nullsec.c
    contiki-3.0/core/net/mac/sicslowmac/: sicslowmac.c
    contiki-3.0/core/net/ipv6/: sicslowpan.c
  group contiki-core
    contiki-3.0/core/sys/: autostart.c ctimer.c etimer.c process.c rtimer.c stimer.c timer.c
    contiki-3.0/cpu/cc253x/dev/: clock.c uart-intr.c uart0.c watchdog.c
    contiki-3.0/core/lib/: list.c memb.c random.c sensors.c
    contiki-3.0/core/net/: packetbuf.c queuebuf.c
    contiki-3.0/cpu/cc253x/: rtimer-arch.c soc.c
  group contiki-dev
    contiki-3.0/dev/ds18b20/: ds18b20-sensor.c ds18b20.c
  group contiki-rpl
    contiki-3.0/core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group contiki-uip6
    contiki-3.0/core/net/: linkaddr.c nbr-table.c
    contiki-3.0/core/net/ip/: tcpip.c uip-debug.c uip-split.c uiplib.c
    contiki-3.0/core/net/ipv6/: uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
